<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>wx_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>32000</value></param>
</block>
<block>
<key>random_source_x</key>
<param><key>id</key><value>random_source_x_0</value></param>
<param><key>type</key><value>short</value></param>
<param><key>min</key><value>0</value></param>
<param><key>max</key><value>1</value></param>
<param><key>num_samps</key><value>1000</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>digital_ofdm_mod</key>
<param><key>id</key><value>digital_ofdm_mod_0</value></param>
<param><key>type</key><value>short</value></param>
<param><key>modulation</key><value>bpsk</value></param>
<param><key>fft_length</key><value>512</value></param>
<param><key>occupied_tones</key><value>200</value></param>
<param><key>cp_length</key><value>128</value></param>
<param><key>pad_for_usrp</key><value>True</value></param>
<param><key>payload_length</key><value>0</value></param>
</block>
<block>
<key>gr_throttle</key>
<param><key>id</key><value>gr_throttle_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>digital_ofdm_demod</key>
<param><key>id</key><value>digital_ofdm_demod_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>modulation</key><value>bpsk</value></param>
<param><key>fft_length</key><value>512</value></param>
<param><key>occupied_tones</key><value>200</value></param>
<param><key>cp_length</key><value>128</value></param>
<param><key>snr</key><value>10</value></param>
</block>
<block>
<key>wxgui_numbersink2</key>
<param><key>id</key><value>wxgui_numbersink2_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>title</key><value>Number Plot</value></param>
<param><key>units</key><value>Units</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>min_value</key><value>-100</value></param>
<param><key>max_value</key><value>100</value></param>
<param><key>factor</key><value>1.0</value></param>
<param><key>decimal_places</key><value>10</value></param>
<param><key>ref_level</key><value>0</value></param>
<param><key>number_rate</key><value>15</value></param>
<param><key>peak_hold</key><value>False</value></param>
<param><key>average</key><value>False</value></param>
<param><key>avg_alpha</key><value>0</value></param>
<param><key>show_gauge</key><value>True</value></param>
</block>
<connection><source_block_id>random_source_x_0</source_block_id><sink_block_id>digital_ofdm_mod_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_ofdm_mod_0</source_block_id><sink_block_id>gr_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_throttle_0</source_block_id><sink_block_id>digital_ofdm_demod_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_ofdm_demod_0</source_block_id><sink_block_id>wxgui_numbersink2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
